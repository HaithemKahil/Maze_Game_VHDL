CIRCUIT D:\systeme_embarqué\TP_layout\mw03\Export Microwind\Add4.MSK
*
* IC Technology: CMOS 0.12µm - 6 Metal
*
VDD 1 0 DC 1.20
VA[1] 54 0 PULSE(0.00 1.20 0.98N 0.02N 0.02N 0.98N 2.00N)
VA[0] 55 0 PULSE(0.00 1.20 0.48N 0.02N 0.02N 0.48N 1.00N)
VB[0] 56 0 PULSE(0.00 1.20 0.98N 0.02N 0.02N 0.98N 2.00N)
VB[1] 57 0 PULSE(0.00 1.20 1.98N 0.02N 0.02N 1.98N 4.00N)
VB[2] 58 0 PULSE(0.00 1.20 3.98N 0.02N 0.02N 3.98N 8.00N)
*
* List of nodes
* "Sum[3]" corresponds to n°3
* "Sum[2]" corresponds to n°4
* "Sum[1]" corresponds to n°5
* "Sum[0]" corresponds to n°6
* "N7" corresponds to n°7
* "N8" corresponds to n°8
* "N9" corresponds to n°9
* "Sum[4]" corresponds to n°16
* "CarryOut" corresponds to n°19
* " xor2_w4" corresponds to n°35
* "A[3]" corresponds to n°52
* "A[2]" corresponds to n°53
* "A[1]" corresponds to n°54
* "A[0]" corresponds to n°55
* "B[0]" corresponds to n°56
* "B[1]" corresponds to n°57
* "B[2]" corresponds to n°58
* "B[3]" corresponds to n°59
* "CarryIn" corresponds to n°60
*
* MOS devices
MN1 0 7 3 0 N1  W= 0.24U L= 0.12U
MN2 0 8 4 0 N1  W= 0.24U L= 0.12U
MN3 0 9 5 0 N1  W= 0.24U L= 0.12U
MN4 0 10 6 0 N1  W= 0.24U L= 0.12U
MN5 32 17 7 0 N1  W= 0.24U L= 0.12U
MN6 33 18 8 0 N1  W= 0.24U L= 0.12U
MN7 34 19 9 0 N1  W= 0.24U L= 0.12U
MN8 35 0 10 0 N1  W= 0.24U L= 0.12U
MN9 0 32 11 0 N1  W= 0.24U L= 0.12U
MN10 0 33 12 0 N1  W= 0.24U L= 0.12U
MN11 0 34 13 0 N1  W= 0.24U L= 0.12U
MN12 0 35 14 0 N1  W= 0.24U L= 0.12U
MN13 0 28 16 0 N1  W= 0.24U L= 0.12U
MN14 0 29 17 0 N1  W= 0.24U L= 0.12U
MN15 0 30 18 0 N1  W= 0.24U L= 0.12U
MN16 0 31 19 0 N1  W= 0.24U L= 0.12U
MN17 28 0 44 0 N1  W= 0.24U L= 0.12U
MN18 29 58 45 0 N1  W= 0.24U L= 0.12U
MN19 30 57 46 0 N1  W= 0.24U L= 0.12U
MN20 31 56 47 0 N1  W= 0.24U L= 0.12U
MN21 44 0 28 0 N1  W= 0.24U L= 0.12U
MN22 45 0 29 0 N1  W= 0.24U L= 0.12U
MN23 46 54 30 0 N1  W= 0.24U L= 0.12U
MN24 47 55 31 0 N1  W= 0.24U L= 0.12U
MN25 0 17 44 0 N1  W= 0.24U L= 0.12U
MN26 0 18 45 0 N1  W= 0.24U L= 0.12U
MN27 0 19 46 0 N1  W= 0.24U L= 0.12U
MN28 0 0 47 0 N1  W= 0.24U L= 0.12U
MN29 48 0 0 0 N1  W= 0.24U L= 0.12U
MN30 49 58 0 0 N1  W= 0.24U L= 0.12U
MN31 50 57 0 0 N1  W= 0.24U L= 0.12U
MN32 51 56 0 0 N1  W= 0.24U L= 0.12U
MN33 28 0 48 0 N1  W= 0.24U L= 0.12U
MN34 29 0 49 0 N1  W= 0.24U L= 0.12U
MN35 30 54 50 0 N1  W= 0.24U L= 0.12U
MN36 31 55 51 0 N1  W= 0.24U L= 0.12U
MN37 0 36 32 0 N1  W= 0.24U L= 0.12U
MN38 0 37 33 0 N1  W= 0.24U L= 0.12U
MN39 0 38 34 0 N1  W= 0.24U L= 0.12U
MN40 0 39 35 0 N1  W= 0.24U L= 0.12U
MN41 0 0 36 0 N1  W= 0.24U L= 0.12U
MN42 0 58 37 0 N1  W= 0.24U L= 0.12U
MN43 54 57 38 0 N1  W= 0.24U L= 0.12U
MN44 55 56 39 0 N1  W= 0.24U L= 0.12U
MN45 0 0 40 0 N1  W= 0.24U L= 0.12U
MN46 0 0 41 0 N1  W= 0.24U L= 0.12U
MN47 0 54 42 0 N1  W= 0.24U L= 0.12U
MN48 0 55 43 0 N1  W= 0.24U L= 0.12U
MP1 1 7 3 1 P1  W= 0.72U L= 0.12U
MP2 1 8 4 1 P1  W= 0.72U L= 0.12U
MP3 1 9 5 1 P1  W= 0.72U L= 0.12U
MP4 1 10 6 1 P1  W= 0.72U L= 0.12U
MP5 11 17 7 1 P1  W= 0.72U L= 0.12U
MP6 12 18 8 1 P1  W= 0.72U L= 0.12U
MP7 13 19 9 1 P1  W= 0.72U L= 0.12U
MP8 14 0 10 1 P1  W= 0.72U L= 0.12U
MP9 1 32 11 1 P1  W= 0.72U L= 0.12U
MP10 1 33 12 1 P1  W= 0.72U L= 0.12U
MP11 1 34 13 1 P1  W= 0.72U L= 0.12U
MP12 1 35 14 1 P1  W= 0.72U L= 0.12U
MP13 1 28 16 1 P1  W= 0.72U L= 0.12U
MP14 1 29 17 1 P1  W= 0.72U L= 0.12U
MP15 1 30 18 1 P1  W= 0.72U L= 0.12U
MP16 1 31 19 1 P1  W= 0.72U L= 0.12U
MP17 24 0 20 1 P1  W= 0.72U L= 0.12U
MP18 25 58 21 1 P1  W= 0.72U L= 0.12U
MP19 26 57 22 1 P1  W= 0.72U L= 0.12U
MP20 27 56 23 1 P1  W= 0.72U L= 0.12U
MP21 28 0 24 1 P1  W= 0.72U L= 0.12U
MP22 29 0 25 1 P1  W= 0.72U L= 0.12U
MP23 30 54 26 1 P1  W= 0.72U L= 0.12U
MP24 31 55 27 1 P1  W= 0.72U L= 0.12U
MP25 20 17 28 1 P1  W= 0.72U L= 0.12U
MP26 21 18 29 1 P1  W= 0.72U L= 0.12U
MP27 22 19 30 1 P1  W= 0.72U L= 0.12U
MP28 23 0 31 1 P1  W= 0.72U L= 0.12U
MP29 1 0 20 1 P1  W= 0.72U L= 0.12U
MP30 1 58 21 1 P1  W= 0.72U L= 0.12U
MP31 1 57 22 1 P1  W= 0.72U L= 0.12U
MP32 1 56 23 1 P1  W= 0.72U L= 0.12U
MP33 20 0 1 1 P1  W= 0.72U L= 0.12U
MP34 21 0 1 1 P1  W= 0.72U L= 0.12U
MP35 22 54 1 1 P1  W= 0.72U L= 0.12U
MP36 23 55 1 1 P1  W= 0.72U L= 0.12U
MP37 1 36 32 1 P1  W= 0.72U L= 0.12U
MP38 1 37 33 1 P1  W= 0.72U L= 0.12U
MP39 1 38 34 1 P1  W= 0.72U L= 0.12U
MP40 1 39 35 1 P1  W= 0.72U L= 0.12U
MP41 40 0 36 1 P1  W= 0.72U L= 0.12U
MP42 41 58 37 1 P1  W= 0.72U L= 0.12U
MP43 42 57 38 1 P1  W= 0.72U L= 0.12U
MP44 43 56 39 1 P1  W= 0.72U L= 0.12U
MP45 1 0 40 1 P1  W= 0.72U L= 0.12U
MP46 1 0 41 1 P1  W= 0.72U L= 0.12U
MP47 1 54 42 1 P1  W= 0.72U L= 0.12U
MP48 1 55 43 1 P1  W= 0.72U L= 0.12U
*
C2 1 0 30.962fF
C3 3 0  0.529fF
C4 4 0  0.529fF
C5 5 0  0.529fF
C6 6 0  0.529fF
C7 7 0  0.680fF
C8 8 0  0.680fF
C9 9 0  0.680fF
C10 10 0  0.680fF
C11 11 0  0.524fF
C12 12 0  0.524fF
C13 13 0  0.524fF
C14 14 0  0.524fF
C16 16 0  0.461fF
C17 17 0  1.303fF
C18 18 0  1.303fF
C19 19 0  1.303fF
C20 20 0  0.723fF
C21 21 0  0.723fF
C22 22 0  0.723fF
C23 23 0  0.723fF
C24 24 0  0.186fF
C25 25 0  0.186fF
C26 26 0  0.186fF
C27 27 0  0.186fF
C28 28 0  0.912fF
C29 29 0  0.912fF
C30 30 0  0.912fF
C31 31 0  0.912fF
C32 32 0  1.179fF
C33 33 0  1.179fF
C34 34 0  1.179fF
C35 35 0  1.179fF
C36 36 0  0.680fF
C37 37 0  0.680fF
C38 38 0  0.680fF
C39 39 0  0.680fF
C40 40 0  0.524fF
C41 41 0  0.524fF
C42 42 0  0.524fF
C43 43 0  0.524fF
C44 44 0  0.362fF
C45 45 0  0.362fF
C46 46 0  0.362fF
C47 47 0  0.362fF
C48 48 0  0.090fF
C49 49 0  0.090fF
C50 50 0  0.090fF
C51 51 0  0.090fF
C54 54 0  1.283fF
C55 55 0  1.283fF
C56 56 0  1.218fF
C57 57 0  1.218fF
C58 58 0  1.218fF
*
* n-MOS Model 3 :
* low leakage
.MODEL N1 NMOS LEVEL=3 VTO=0.40 UO=600.000 TOX= 2.0E-9
+LD =0.000U THETA=0.500 GAMMA=0.400
+PHI=0.200 KAPPA=0.060 VMAX=120.00K
+CGSO=100.0p CGDO=100.0p
+CGBO= 60.0p CJSW=240.0p
*
* p-MOS Model 3:
* low leakage
.MODEL P1 PMOS LEVEL=3 VTO=-0.45 UO=200.000 TOX= 2.0E-9
+LD =0.000U THETA=0.300 GAMMA=0.400
+PHI=0.200 KAPPA=0.060 VMAX=110.00K
+CGSO=100.0p CGDO=100.0p
+CGBO= 60.0p CJSW=240.0p
*
* Transient analysis
*
.TEMP 27.0
.TRAN 0.1N 5.00N
* (Pspice)
.PROBE
.END
